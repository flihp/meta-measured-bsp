COMPATIBLE_MACHINE_edison-tpm = "edison-tpm"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
